/*$T win32SNDdebug.h GC! 1.081 02/06/03 18:34:20 */


/*$6
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 */


#ifndef __win32SNDdebug_h__
#define __win32SNDdebug_h__

#if defined (__cplusplus) && !defined(JADEFUSION)
extern "C"
{
#endif

/*$4
 ***********************************************************************************************************************
 ***********************************************************************************************************************
 */
#ifdef _DEBUG
#define WIN32_SND_ASSERT_IS_ENABLED
#endif

#ifdef WIN32_SND_ASSERT_IS_ENABLED

/*$2
 -----------------------------------------------------------------------------------------------------------------------
    ASSERT ENABLED
 -----------------------------------------------------------------------------------------------------------------------
 */

#define win32SND_M_Assert(hr) \
	do \
	{ \
		if(!(hr)) \
		{ \
			win32SND_Assert(#hr, __FILE__, __LINE__); \
			__asm \
			{ \
				int 0x03 \
			}; \
		} \
	} while(0);

#define win32SND_M_HAssert(hr) \
	do \
	{ \
		if((hr) != DS_OK) \
		{ \
			win32SND_CheckHRESULT(hr); \
		} \
	} while(0);

void	win32SND_CheckHRESULT(HRESULT hr);
void	win32SND_Assert(char *, char *, int line);
#else

/*$2
 -----------------------------------------------------------------------------------------------------------------------
    ASSERT DISABLED
 -----------------------------------------------------------------------------------------------------------------------
 */

#define win32SND_M_Assert(hr)
void	win32SND_CheckHRESULT(HRESULT hr);

#endif

/*$4
 ***********************************************************************************************************************
    EOF
 ***********************************************************************************************************************
 */

#if defined (__cplusplus) && !defined(JADEFUSION)
}
#endif
#endif /* __win32SNDdebug_h__ */
