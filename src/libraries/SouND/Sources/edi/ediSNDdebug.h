/*$T ediSNDdebug.h GC! 1.081 02/06/03 18:34:20 */


/*$6
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 */


#ifndef __ediSNDdebug_h__
#define __ediSNDdebug_h__

#if defined (__cplusplus) && !defined(JADEFUSION)
extern "C"
{
#endif

/*$4
 ***********************************************************************************************************************
 ***********************************************************************************************************************
 */
#ifdef _DEBUG
#define ediSND_ENABLE_ASSERT
#endif

#ifdef ediSND_ENABLE_ASSERT

/*$2
 -----------------------------------------------------------------------------------------------------------------------
    ASSERT ENABLED
 -----------------------------------------------------------------------------------------------------------------------
 */

#define ediSND_M_Assert(hr) \
	do \
	{ \
		if(!(hr)) \
		{ \
			ediSND_Assert(#hr, __FILE__, __LINE__); \
			__asm \
			{ \
				int 0x03 \
			}; \
		} \
	} while(0);

#define ediSND_M_HAssert(hr) \
	do \
	{ \
		if((hr) != DS_OK) \
		{ \
			ediSND_CheckHRESULT(hr); \
		} \
	} while(0);

void	ediSND_CheckHRESULT(HRESULT hr);
void	ediSND_Assert(char *, char *, int line);
#else

/*$2
 -----------------------------------------------------------------------------------------------------------------------
    ASSERT DISABLED
 -----------------------------------------------------------------------------------------------------------------------
 */

#define ediSND_M_Assert(hr)
#endif

/*$4
 ***********************************************************************************************************************
    EOF
 ***********************************************************************************************************************
 */

#if defined (__cplusplus) && !defined(JADEFUSION)
}
#endif
#endif /* __ediSNDdebug_h__ */
