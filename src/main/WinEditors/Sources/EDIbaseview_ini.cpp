/*$T EDIbaseview_ini.cpp GC!1.38 05/21/99 18:39:00 */

/*
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 +++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
 */

#include "Precomp.h"
#ifdef ACTIVE_EDITORS
#include "BASe/CLIbrary/CLIstr.h"
#include "BASe/ERRors/ERRasser.h"
#include "EDIbaseview.h"
#include "EDIbaseframe.h"
#include "EDImainframe.h"

/*
 ===================================================================================================
 ===================================================================================================
 */
void EDI_cl_BaseView::SaveIni(void)
{
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
    int i;
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/

    /* Call SaveIni for all editors */
    for(i = 0; i < M_CurNumEd(mi_NumPane); i++)
    {
        if(M_CurEd(mi_NumPane, i).po_Editor)
            M_CurEd(mi_NumPane, i).po_Editor->SaveIni();
    }
}

/*
 ===================================================================================================
 ===================================================================================================
 */
void EDI_cl_BaseView::LoadIniDesktop(void)
{
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
    int i;
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/

    for(i = 0; i < M_CurNumEd(mi_NumPane); i++)
    {
        if(M_CurEd(mi_NumPane, i).po_Editor)
            M_CurEd(mi_NumPane, i).po_Editor->LoadIniDesktop();
    }
}

/*
 ===================================================================================================
 ===================================================================================================
 */
void EDI_cl_BaseView::TreatIni(void)
{
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/
    int i;
    /*~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~*/

    for(i = 0; i < M_CurNumEd(mi_NumPane); i++)
    {
        if(M_CurEd(mi_NumPane, i).po_Editor)
            M_CurEd(mi_NumPane, i).po_Editor->TreatIni();
    }
}

#endif /* ACTIVE_EDITORS */
